# Keil uVision project tenx51-78.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5268B tenx
  cpu: IRAM(0-0xFF) CLOCK(8000000)
  output: tenx51-78 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP_TENX52.A51 buzz.c display.c init.c isr.c keys.c main.c triac.c
